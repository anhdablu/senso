FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://seesaw-i2c.cfg"
